// TOH IR firmware v0.4 (RP2040-Zero): the TOH DevKit firmware (I2C target 0x42, DevKit registers kept, so the DevKit
// app keeps working) plus IR send/learn over I2C for the TOH IR app, and a USB serial console for debugging.
// Board: Waveshare RP2040-Zero, Arduino core "Raspberry Pi Pico/RP2040" by Earle Philhower (rp2040:rp2040).
//
// Wiring (pin numbers as printed on the Zero):
//   I2C from the breakout: SDA -> 26, SCL -> 15.
//   IR receiver module:    OUT -> 14, VCC -> 28,  GND -> GND   (output is low while it sees a 38 kHz burst)
//                          v0.4: 28 powers the receiver only while learning (or in loopback / monitor mode), so the
//                          module's signal LED stays dark and it draws nothing the rest of the time.
//   IR transmitter module: DAT -> 7,  VCC -> 3V3, GND -> GND   (carrier generated by PWM on 7)
//   (The DevKit's LED on 14 is gone; register 0x14 is still accepted but does nothing.)
//
// I2C registers (address 0x42): write [reg, data...] / write [reg] then read. The pointer auto-increments, except on
// the two data ports, which stream bytes through one register.
//   0x00-0x0F  DevKit: "TOHD", version, uptime; 0x10-0x12 RGB LED; 0xF0 = 0xB0 -> USB bootloader
//   0x20-0x22  R   "IR", IR interface version (1)
//   0x23       R   status: bit0 learned frame ready, bit1 learning, bit2 sending, bit3 learned frame truncated
//   0x24       W   command: 1 send TX buffer, 2 learn (wait for one frame), 3 cancel learning,
//                           4 reset TX buffer, 5 rewind RX read position
//   0x25       RW  carrier for sending, kHz (default 38)
//   0x26-0x27  RW  number of durations to send (uint16 LE)
//   0x28-0x29  R   number of durations in the learned frame (uint16 LE)
//   0x2A-0x2B  R   checksum of the learned frame's bytes (sum mod 65536)
//   0x2C-0x2D  R   checksum of the bytes written to the TX port since "reset TX buffer"
//   0x2E-0x2F  R   number of bytes written to the TX port since "reset TX buffer"
//   0x30       W   TX port: durations as uint16 LE, microseconds, mark first (mark, space, mark, ...)
//   0x31       R   RX port: the learned frame, same format
//
// USB serial (115200), one command per line: t (self-test: send NEC 0x00/0x45), s (send last received frame),
// l (loopback on/off: keep the receiver listening while sending, to check what goes out; off after a restart),
// r (monitor on/off: receiver always on, prints every frame; off after a restart).
// Every received frame is printed as "RAW <n>: +mark -space ...". Learning gives up by itself after 60 s.
//
// I2C core: see ../../../toh-devkit/firmware/devkit-fw/devkit-fw.ino for why core 1 polls the I2C block from RAM.
// v0.2 fix for the DevKit's lock-up: a pending TX abort is cleared BEFORE answering a read request. While the abort
// flag is set the TX FIFO discards writes, so the answer got lost and the RP2040 held SCL low forever.
#include <hardware/i2c.h>
#include <hardware/gpio.h>
#include <hardware/pwm.h>
#include <hardware/clocks.h>
#include <Adafruit_NeoPixel.h>

const uint8_t ADDR = 0x42, PIN_SDA = 26, PIN_SCL = 15, PIN_LED = 16;
const uint8_t PIN_IR_RX = 14, PIN_IR_TX = 7, PIN_IR_PWR = 28;
#define I2C_HW i2c1
const uint8_t VER_MAJOR = 0, VER_MINOR = 4, IR_VER = 1;
const uint8_t REG_UPTIME = 0x06, REG_LED = 0x10, REG_BOOT = 0xF0, BOOT_MAGIC = 0xB0;
const uint8_t REG_IR = 0x20, REG_STATUS = 0x23, REG_CMD = 0x24, REG_CARRIER = 0x25, REG_TXCOUNT = 0x26,
              REG_RXCOUNT = 0x28, REG_RXSUM = 0x2A, REG_TXSUM = 0x2C, REG_TXLEN = 0x2E, REG_TXPORT = 0x30,
              REG_RXPORT = 0x31;
const uint8_t CMD_SEND = 1, CMD_LEARN = 2, CMD_CANCEL = 3, CMD_TXRESET = 4, CMD_RXREWIND = 5;
const int MAX_DUR = 2048, BUF_BYTES = MAX_DUR * 2;

Adafruit_NeoPixel led(1, PIN_LED, NEO_RGB + NEO_KHZ800);
volatile uint8_t regs[256];
volatile bool ledDirty = true, bootReq = false;
volatile uint8_t txBytes[BUF_BYTES], rxBytes[BUF_BYTES];
volatile uint16_t txPos = 0, txSum = 0, rxPos = 0;
volatile bool stReady = false, stLearning = false, stSending = false, stTrunc = false;
volatile uint8_t pendingCmd = 0;
bool loopback = false, monitor = false;

// ---------------- I2C target (core 1) ----------------
static void __not_in_flash_func(snapshotUptime)() {
  uint32_t t = millis();
  for (int i = 0; i < 4; i++) regs[REG_UPTIME + i] = (t >> (8 * i)) & 0xFF;
}

static void __not_in_flash_func(i2cTargetLoop)() {
  i2c_hw_t *h = I2C_HW->hw;
  uint8_t ptr = 0;
  for (;;) {
    uint32_t raw = h->raw_intr_stat;
    if (raw & I2C_IC_RAW_INTR_STAT_TX_ABRT_BITS) (void)h->clr_tx_abrt;   // first, see header
    if (raw & I2C_IC_RAW_INTR_STAT_RD_REQ_BITS) {
      uint8_t v;
      if (ptr == REG_RXPORT) v = rxPos < BUF_BYTES ? rxBytes[rxPos++] : 0;
      else if (ptr == REG_STATUS) { v = stReady | stLearning << 1 | stSending << 2 | stTrunc << 3; ptr++; }
      else v = regs[ptr++];
      h->data_cmd = v;
      (void)h->clr_rd_req;
    }
    while (h->status & I2C_IC_STATUS_RFNE_BITS) {
      uint32_t dc = h->data_cmd;
      uint8_t v = dc & 0xFF;
      if (dc & I2C_IC_DATA_CMD_FIRST_DATA_BYTE_BITS) {
        ptr = v;
        if (ptr <= REG_UPTIME + 3) snapshotUptime();
      } else if (ptr == REG_TXPORT) {
        if (txPos < BUF_BYTES) { txBytes[txPos++] = v; txSum += v; }
        regs[REG_TXSUM] = txSum & 0xFF; regs[REG_TXSUM + 1] = txSum >> 8;
        regs[REG_TXLEN] = txPos & 0xFF; regs[REG_TXLEN + 1] = txPos >> 8;
      } else {
        if (ptr >= REG_LED && ptr <= REG_LED + 2) { regs[ptr] = v; ledDirty = true; }
        else if (ptr == REG_BOOT && v == BOOT_MAGIC) bootReq = true;
        else if (ptr == REG_CARRIER || ptr == REG_TXCOUNT || ptr == REG_TXCOUNT + 1) regs[ptr] = v;
        else if (ptr == REG_CMD) {
          if (v == CMD_TXRESET) {
            txPos = 0; txSum = 0;
            regs[REG_TXSUM] = regs[REG_TXSUM + 1] = regs[REG_TXLEN] = regs[REG_TXLEN + 1] = 0;
          } else if (v == CMD_RXREWIND) rxPos = 0;
          else if (v == CMD_SEND) { stSending = true; pendingCmd = v; }
          else if (v == CMD_LEARN) { stReady = false; stTrunc = false; stLearning = true; pendingCmd = v; }
          else if (v == CMD_CANCEL) { stLearning = false; pendingCmd = v; }
        }
        ptr++;
      }
    }
    if (raw & I2C_IC_RAW_INTR_STAT_STOP_DET_BITS) (void)h->clr_stop_det;
    if (raw & I2C_IC_RAW_INTR_STAT_START_DET_BITS) (void)h->clr_start_det;
    if (raw & I2C_IC_RAW_INTR_STAT_RESTART_DET_BITS) (void)h->clr_restart_det;
  }
}

void setup1() {
  i2c_init(I2C_HW, 1000000);
  i2c_set_slave_mode(I2C_HW, true, ADDR);
  gpio_set_function(PIN_SDA, GPIO_FUNC_I2C);
  gpio_set_function(PIN_SCL, GPIO_FUNC_I2C);
  gpio_pull_up(PIN_SDA);
  gpio_pull_up(PIN_SCL);
  i2cTargetLoop();
}
void loop1() {}

// ---------------- IR receive: edge interrupt records durations ----------------
const uint32_t FRAME_GAP_US = 80000;   // silence that ends a frame
volatile uint32_t rxBuf[MAX_DUR + 1];
volatile int rxN = 0;
volatile uint32_t rxLast = 0;
volatile bool rxOverflow = false;
uint32_t lastFrame[MAX_DUR];
int lastN = 0;

void __not_in_flash_func(onRxEdge)() {
  uint32_t now = time_us_32();
  bool level = gpio_get(PIN_IR_RX);
  if (rxN == 0) {
    if (level) return;                   // a frame starts with a mark (output goes low)
    rxLast = now; rxN = 1;
    return;
  }
  if (rxN <= MAX_DUR) rxBuf[rxN++] = now - rxLast; else rxOverflow = true;
  rxLast = now;
}

// ---------------- receiver power (pin 28) ----------------
const uint32_t RX_SETTLE_MS = 50, LEARN_TIMEOUT_MS = 60000;
bool rxOn = false;

void rxPower(bool on) {
  if (on == rxOn) return;
  rxOn = on;
  if (on) {
    gpio_put(PIN_IR_PWR, 1);
    delay(RX_SETTLE_MS);                 // the receiver's AGC settles; its output may glitch meanwhile
    gpio_set_pulls(PIN_IR_RX, true, false);
    delay(1);
    noInterrupts(); rxN = 0; rxOverflow = false; interrupts();
    gpio_set_irq_enabled(PIN_IR_RX, GPIO_IRQ_EDGE_RISE | GPIO_IRQ_EDGE_FALL, true);
  } else {
    gpio_set_irq_enabled(PIN_IR_RX, GPIO_IRQ_EDGE_RISE | GPIO_IRQ_EDGE_FALL, false);
    gpio_set_pulls(PIN_IR_RX, false, true);   // no pull-up feeding the unpowered module through OUT
    gpio_put(PIN_IR_PWR, 0);
    noInterrupts(); rxN = 0; interrupts();
  }
}

// ---------------- IR send: PWM carrier on the TX pin ----------------
uint txSlice, txChan;

void txSetCarrier(uint32_t khz) {
  if (khz < 20 || khz > 60) khz = 38;
  pwm_set_clkdiv(txSlice, 1.0f);
  pwm_set_wrap(txSlice, clock_get_hz(clk_sys) / (khz * 1000) - 1);
}
inline void txMark(bool on) {
  uint32_t wrap = pwm_hw->slice[txSlice].top;
  pwm_set_chan_level(txSlice, txChan, on ? (wrap + 1) / 3 : 0);   // 33 % duty cycle
}
void txInit() {
  gpio_set_function(PIN_IR_TX, GPIO_FUNC_PWM);
  txSlice = pwm_gpio_to_slice_num(PIN_IR_TX);
  txChan = pwm_gpio_to_channel(PIN_IR_TX);
  txSetCarrier(38);
  txMark(false);
  pwm_set_enabled(txSlice, true);
}

uint32_t durAt(const volatile uint8_t *b, int i) { return (uint32_t)b[2 * i] | (uint32_t)b[2 * i + 1] << 8; }

// Durations (microseconds), first one a mark. Either a uint32 array or (bytes != null) uint16 LE bytes.
// The receiver is paused meanwhile.
void irSend(const uint32_t *d, const volatile uint8_t *bytes, int n) {
  if (!loopback) gpio_set_irq_enabled(PIN_IR_RX, GPIO_IRQ_EDGE_RISE | GPIO_IRQ_EDGE_FALL, false);
  uint32_t t = time_us_32();
  for (int i = 0; i < n; i++) {
    txMark(i % 2 == 0);
    t += bytes ? durAt(bytes, i) : d[i];
    while ((int32_t)(time_us_32() - t) < 0) {}
  }
  txMark(false);
  if (loopback || !rxOn) return;
  delay(5);                              // let the receiver settle before listening again
  noInterrupts(); rxN = 0; interrupts();
  gpio_set_irq_enabled(PIN_IR_RX, GPIO_IRQ_EDGE_RISE | GPIO_IRQ_EDGE_FALL, true);
}

int necBuild(uint8_t addr, uint8_t cmd, uint32_t *d) {
  int n = 0;
  d[n++] = 9000; d[n++] = 4500;
  uint32_t bits = addr | (uint32_t)(uint8_t)~addr << 8 | (uint32_t)cmd << 16 | (uint32_t)(uint8_t)~cmd << 24;
  for (int i = 0; i < 32; i++) { d[n++] = 560; d[n++] = (bits >> i) & 1 ? 1690 : 560; }
  d[n++] = 560;
  return n;
}

void showColor(uint8_t r, uint8_t g, uint8_t b) { led.setPixelColor(0, led.Color(r, g, b)); led.show(); }

// ---------------- core 0 ----------------
void setup() {
  Serial.begin(115200);
  regs[0] = 'T'; regs[1] = 'O'; regs[2] = 'H'; regs[3] = 'D';
  regs[4] = VER_MAJOR; regs[5] = VER_MINOR;
  regs[REG_LED] = 0; regs[REG_LED + 1] = 0; regs[REG_LED + 2] = 8;
  regs[REG_IR] = 'I'; regs[REG_IR + 1] = 'R'; regs[REG_IR + 2] = IR_VER;
  regs[REG_CARRIER] = 38;
  led.begin();
  pinMode(PIN_IR_PWR, OUTPUT);
  digitalWrite(PIN_IR_PWR, LOW);
  gpio_set_drive_strength(PIN_IR_PWR, GPIO_DRIVE_STRENGTH_12MA);
  pinMode(PIN_IR_RX, INPUT_PULLDOWN);
  attachInterrupt(digitalPinToInterrupt(PIN_IR_RX), onRxEdge, CHANGE);
  gpio_set_irq_enabled(PIN_IR_RX, GPIO_IRQ_EDGE_RISE | GPIO_IRQ_EDGE_FALL, false);   // receiver starts off
  txInit();
}

static String line;
uint32_t learnStart = 0;

void storeLearned(const uint32_t *d, int n, bool trunc) {
  uint16_t sum = 0;
  for (int i = 0; i < n; i++) {
    uint32_t v = d[i] > 65535 ? 65535 : d[i];
    rxBytes[2 * i] = v & 0xFF; rxBytes[2 * i + 1] = v >> 8;
    sum += (v & 0xFF) + (v >> 8);
  }
  regs[REG_RXCOUNT] = n & 0xFF; regs[REG_RXCOUNT + 1] = n >> 8;
  regs[REG_RXSUM] = sum & 0xFF; regs[REG_RXSUM + 1] = sum >> 8;
  rxPos = 0;
  stTrunc = trunc;
  stLearning = false;
  stReady = true;
}

void loop() {
  if (ledDirty) {
    ledDirty = false;
    showColor(regs[REG_LED], regs[REG_LED + 1], regs[REG_LED + 2]);
  }

  uint8_t cmd = pendingCmd;
  if (cmd) {
    pendingCmd = 0;
    if (cmd == CMD_SEND) {
      int n = regs[REG_TXCOUNT] | regs[REG_TXCOUNT + 1] << 8;
      if (n > txPos / 2) n = txPos / 2;
      txSetCarrier(regs[REG_CARRIER]);
      showColor(0, 0, 60);
      irSend(nullptr, txBytes, n);
      stSending = false;
      ledDirty = true;
    } else if (cmd == CMD_LEARN) {
      noInterrupts(); rxN = 0; interrupts();   // only frames that start after the command count
      learnStart = millis();
      showColor(40, 20, 0);
    } else if (cmd == CMD_CANCEL) {
      ledDirty = true;
    }
  }

  if (stLearning && millis() - learnStart > LEARN_TIMEOUT_MS) { stLearning = false; ledDirty = true; }
  rxPower(stLearning || loopback || monitor);

  // frame finished?
  noInterrupts();
  bool done = rxN > 1 && (time_us_32() - rxLast) > FRAME_GAP_US;
  int n = 0;
  if (done) {
    n = rxN - 1;
    for (int i = 0; i < n; i++) lastFrame[i] = rxBuf[i + 1];
    rxN = 0;
  }
  bool ovf = rxOverflow; rxOverflow = false;
  interrupts();
  if (done) {
    if (n % 2 == 0) n--;                   // ends with a mark; a trailing space is the gap
    lastN = n;
    Serial.printf("RAW %d:", n);
    for (int i = 0; i < n; i++) Serial.printf(" %c%lu", i % 2 ? '-' : '+', lastFrame[i]);
    Serial.println(ovf ? "  (TRUNCATED)" : "");
    if (stLearning && n >= 7) {             // shorter bursts are noise or a bare repeat code
      storeLearned(lastFrame, n, ovf);
      showColor(0, 60, 0); delay(150); ledDirty = true;
      Serial.println("  -> stored as learned frame");
    }
  }

  while (Serial.available()) {
    char c = Serial.read();
    if (c == '\n' || c == '\r') {
      line.trim();
      if (line == "t") { uint32_t d[80]; int k = necBuild(0x00, 0x45, d); txSetCarrier(38); irSend(d, nullptr, k); Serial.println("sent NEC 0x00/0x45"); }
      else if (line == "l") { loopback = !loopback; Serial.printf("loopback %s\n", loopback ? "on" : "off"); }
      else if (line == "r") { monitor = !monitor; Serial.printf("monitor %s\n", monitor ? "on" : "off"); }
      else if (line == "s" && lastN) { txSetCarrier(38); irSend(lastFrame, nullptr, lastN); Serial.println("sent last frame"); }
      line = "";
    } else if (line.length() < 64) line += c;
  }
  if (bootReq) { delay(20); rp2040.rebootToBootloader(); }
}
